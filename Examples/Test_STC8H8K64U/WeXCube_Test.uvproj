# Keil uVision project WeXCube_Test.uvproj, settings and files
target Firmware (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: WeXCube_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\wexcube_sdk
  group Startup
    ./: STARTUP.A51
  group User
    ./User/: main.c
  group wexcube_sdk
    ./wexcube_sdk/: wexcube_port.h wexcube_config.h wexcube.h wexcube_port.c wexcube.c
