# Keil uVision project WeXCube_Test.uvproj, settings and files
target Firmware (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: WeXCube_Test +hex
  group User
    ./User/: main.c stc32g.h
  group wexcube_sdk
    ./wexcube_sdk/: wexcube.c wexcube_port.c wexcube.h wexcube_config.h wexcube_port.h
